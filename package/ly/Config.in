## package/ly/Config.in
```kconfig
config BR2_PACKAGE_LY
	bool "ly"
	select BR2_PACKAGE_LINUX_PAM
	help
	 A display manager with console UI
```
